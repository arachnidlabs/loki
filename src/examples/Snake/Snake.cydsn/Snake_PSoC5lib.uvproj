# Keil uVision project Snake_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5368AXI-106 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x2E00-0x3FFBF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Snake_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Bootloadable_1.c Bootloadable_1.h Joystick_aliases.h Backlight_aliases.h Backlight.c Backlight.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5368AXI-106 Cypress
  cpu: as above
  output: Snake_PSoC5lib (library)
