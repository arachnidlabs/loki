# Keil uVision project GameOfLife_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5368AXI-106 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x2E00-0x3FFBF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: GameOfLife_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD_1_lcd.c LCD_1_lcd.h LCD_MOSI_aliases.h LCD_MOSI.c LCD_MOSI.h LCD_SCLK_aliases.h LCD_SCLK.c LCD_SCLK.h LCD_D_C_aliases.h LCD_D_C.c LCD_D_C.h LCD_RESET_aliases.h LCD_RESET.c LCD_RESET.h LCD_1_LCD_Control.c LCD_1_LCD_Control.h LCD_1_LCD_SPI.c LCD_1_LCD_SPI.h LCD_1_LCD_SPI_PM.c LCD_1_LCD_SPI_INT.c LCD_1_LCD_DMA_dma.c LCD_1_LCD_DMA_dma.h LCD_1_LCD_SPI_IntClock.c LCD_1_LCD_SPI_IntClock.h PrISM_1.c PrISM_1.h PrISM_1_PM.c LCD_LIGHT_aliases.h LCD_LIGHT.c LCD_LIGHT.h Clock_1.c Clock_1.h EEPROM_1.c EEPROM_1.h Bootloadable_1.c Bootloadable_1.h
target Release (ARM-GNU)
  device: CY8C5368AXI-106 Cypress
  cpu: as above
  output: GameOfLife_PSoC5lib (library)
